Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air_MEPcontent_Spirotech_SpiroVent RV2 UA_UA075W_INT-EN.ifc
Time: 2025-08-05T18:27:10+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection
InPort_1996916_1 | SINK
OutPort_1996916_2 | SOURCE

# IfcValve: M_Separator_Air_MEPcontent_Spirotech_SpiroVent RV2 UA_INT-EN:UA075W, M_Separator_Air_MEPcontent_Spirotech_SpiroVent RV2 UA_INT-EN:UA075W:1996916
In: F00
Type - Material: RGB 168-128-48
Type - Other - Category: Pipe Accessories; Arrow Length: 35 mm; Big Nozzle: no; b Safe: 117.856 mm; Connecting Socket: -23 mm; Connecting Socket Length: 46 mm; D1: 32 mm; D Safe: 31 mm; Family Name: M_Separator_Air_MEPcontent_Spirotech_SpiroVent RV2 UA_INT-EN; Length Blend: 23 mm; Nominal Diameter: 19.05 mm; Nozzle Height: 70 mm; Outer Diameter: 26.9 mm; Outer Diameter Body: 34 mm; Outer Radius: 17 mm; Outer Radius 1: 15 mm; Screw Radius: 20.4 mm; Screw Radius 2: 32 mm; Screw Radius 3: 29 mm; Small Nozzle: yes; Threaded Outer Connection: 34 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - b: 127 mm; D: 62 mm; h: 32 mm; h1: 145 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Deaerator - Brass - Universal 3/4"; Article Type: UA075W; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Deaerator - Brass - Universal 3/4"; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.28; GLN: 8717811000007; GTIN: 8717811049624; Manufacturer: Spirotech; Manufacturer Art. No.: UA075W; Manufacturer URL: https://www.spirotech.com/8717811049624; MEPcontent Class: SEPARATOR_AIR; Model: UA075W; OmniClass Number: 23.75.50.11.14.14; OmniClass Title: Deaerators; Product Line: Spirotech; Revit Version: 2023; Type Name: UA075W; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Air Vent: RGB 168-128-48
Type - Mechanical - Flow-through Capacity: 0.00283 m3/s; Loss Method: Not Defined
Type - Mechanical - Flow - Kv: 0.00283 m3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: UA075W; sets with these values: 2
Other - Family: M_Separator_Air_MEPcontent_Spirotech_SpiroVent RV2 UA_INT-EN; Family and Type: M_Separator_Air_MEPcontent_Spirotech_SpiroVent RV2 UA_INT-EN: UA075W; L Body: 70 mm; L Nut: 10 mm; L Safe: 80 mm; Type: UA075W; Type Id: 1996399
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 0.0121241 m2; d: 19.05 mm; L: 100 mm; Maximum Size: 19.05 mm; Minimum Size: 19.05 mm; Volume: 0.000894542 m3
Graphics - Annotation Offset: 0 mm
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Pressure Drop: 0 Pa
Phasing - Phase Created: 3. New Construction
Insulation - Insulation Thickness: 0 mm
