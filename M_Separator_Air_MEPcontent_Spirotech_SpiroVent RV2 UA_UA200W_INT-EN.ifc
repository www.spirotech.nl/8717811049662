Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air_MEPcontent_Spirotech_SpiroVent RV2 UA_UA200W_INT-EN.ifc
Time: 2025-08-05T18:27:26+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection
InPort_1997412_1 | SINK
OutPort_1997412_2 | SOURCE

# IfcValve: M_Separator_Air_MEPcontent_Spirotech_SpiroVent RV2 UA_INT-EN:UA200W, M_Separator_Air_MEPcontent_Spirotech_SpiroVent RV2 UA_INT-EN:UA200W:1997412
In: F00
Type - Material: RGB 168-128-48
Type - Other - Category: Pipe Accessories; Arrow Length: 71 mm; Big Nozzle: yes; b Safe: 147.552 mm; Connecting Socket: -34 mm; Connecting Socket Length: 68 mm; D1: 68 mm; D Safe: 40 mm; Family Name: M_Separator_Air_MEPcontent_Spirotech_SpiroVent RV2 UA_INT-EN; Length Blend: 34 mm; Nominal Diameter: 50.8 mm; Nozzle Height: 69.97 mm; Outer Diameter: 60.3 mm; Outer Diameter Body: 70 mm; Outer Radius: 35 mm; Outer Radius 1: 33 mm; Screw Radius: 42 mm; Screw Radius 2: 50 mm; Screw Radius 3: 47 mm; Small Nozzle: no; Threaded Outer Connection: 70 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - b: 159 mm; D: 80 mm; h: 50 mm; h1: 246 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Deaerator - Brass - Universal 2"; Article Type: UA200W; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Deaerator - Brass - Universal 2"; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.28; GLN: 8717811000007; GTIN: 8717811049662; Manufacturer: Spirotech; Manufacturer Art. No.: UA200W; Manufacturer URL: https://www.spirotech.com/8717811049662; MEPcontent Class: SEPARATOR_AIR; Model: UA200W; OmniClass Number: 23.75.50.11.14.14; OmniClass Title: Deaerators; Product Line: Spirotech; Revit Version: 2023; Type Name: UA200W; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Air Vent: RGB 168-128-48
Type - Mechanical - Flow-through Capacity: 0.00283 m3/s; Loss Method: Not Defined
Type - Mechanical - Flow - Kv: 0.00283 m3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: UA200W; sets with these values: 2
Other - Family: M_Separator_Air_MEPcontent_Spirotech_SpiroVent RV2 UA_INT-EN; Family and Type: M_Separator_Air_MEPcontent_Spirotech_SpiroVent RV2 UA_INT-EN: UA200W; L Body: 89.6 mm; L Nut: 12.8 mm; L Safe: 102.4 mm; Type: UA200W; Type Id: 1996407
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 0.0121241 m2; d: 50.8 mm; L: 128 mm; Maximum Size: 50.8 mm; Minimum Size: 50.8 mm; Volume: 0.0024607 m3
Graphics - Annotation Offset: 0 mm
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Pressure Drop: 0 Pa
Phasing - Phase Created: 3. New Construction
Insulation - Insulation Thickness: 0 mm
